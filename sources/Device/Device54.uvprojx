# Keil uVision project Device54.uvprojx, settings and files
target Device54 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F437ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Device
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F437xx, __cplusplus, S8_54, OSCI
  c misc: --cpp
  c include: ..\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Src;..\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src;..\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Src;..\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Src;..\libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include;..\libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\system;..\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src\drivers;..\libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\src;..\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\src;.\src\libs;.\src\Ethernet;.\src\VCP;..\libs\common
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Device54.sct
  group HAL
    ../libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_ll_usb.c
    ../libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dma.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_hcd.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_ll_usb.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h
  group USBD
    ../libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c
    ../libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_ctlreq.h usbd_ioreq.h
    ../libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc/: usbd_cdc.h
  group USBH
    ../libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Inc/: usbh_core.h usbh_ctlreq.h usbh_ioreq.h usbh_pipes.h
    ../libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc/: usbh_msc.h usbh_msc_bot.h usbh_msc_scsi.h
    ../libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group FatFS
    ../libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h
    ../libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group LwIP
    ../libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group libs
    ./src/libs/: ffconf.h startup_stm32f437xx.s stm32f4xx_hal_conf.h stm32f4xx_hal_msp.cpp stm32f4xx_it.cpp stm32f4xx_it.h system_stm32f4xx.c usbd_conf.cpp usbd_conf.h usbh_conf.cpp usbh_conf.h usbh_diskio.cpp usbh_diskio.h
  group src
    ./src/: cmsis_gcc.h defines.h FileTree.txt Globals.cpp Globals.h Log.cpp Log.h main.cpp main.h stub54.cpp Tables.cpp Tables.h
    ../libs/common/: commonDefines.cpp commonDefines.h structs.h
  group Data
    ./src/Data/: DataSettings.cpp DataSettings.h DataStorage.cpp DataStorage.h Reader.cpp Reader.h
  group Display
    ../libs/common/Display/: Colors.cpp Colors.h DisplayPrimitives.cpp DisplayPrimitives.h DisplayTypes.h Grid.cpp Grid.h Painter.cpp Painter.h PainterText.cpp
    ./src/Display/: Display.cpp Display.h PainterData.cpp PainterData.h PainterMem.cpp PainterMem.h
  group Display/Font
    ./src/Display/Font/: Font.cpp Font.h font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc
  group Ethernet
    ./src/Ethernet/: app_ethernet.cpp app_ethernet.h Ethernet.cpp Ethernet.h ethernetif.cpp ethernetif.h lwipopts.h TcpSocket.cpp TcpSocket.h
  group FlashDrive
    ./src/FlashDrive/: FileManager.cpp FileManager.h FlashDrive.cpp FlashDrive.h
  group FPGA
    ./src/FPGA/: FPGA.cpp FPGA.h FPGAextensions.cpp FPGAextensions.h fpgaSettings.cpp FPGATypes.cpp FPGATypes.h
    ../libs/common/FPGA/: FPGAMath.cpp FPGAMath.h
  group Hardware
    ./src/Hardware/: FLASH.cpp FLASH.h FSMC.cpp FSMC.h Hardware.cpp Hardware.h RAM.cpp RAM.h RTC.cpp RTC.h
    ../libs/common/Hardware/: Sound.cpp Sound.h Timer.cpp Timer.h
  group Menu
    ./src/Menu/: MenuPagesNames.h
    ../libs/common/Menu/: Menu.cpp Menu.h MenuItems.cpp MenuItems.h MenuItemsDefs.h MenuItemsGraphics.cpp MenuItemsLogic.cpp
  group Menu/Pages
    ./src/Menu/Pages/: HelpContent.cpp HelpContent.h HelpContentPages.h PageChannels.cpp PageCursors.cpp PageCursors.h PageDebug.cpp PageDisplay.cpp PageDisplay.h PageHelp.cpp PageHelp.h PageMeasures.cpp PageMemory.cpp PageMemory.h PageService.cpp PageTime.cpp PageTrig.cpp
    ../libs/common/Menu/Pages/: Definition.cpp Definition.h
  group Panel
    ./src/Panel/: Controls.cpp Controls.h Panel.cpp Panel.h PanelFunctions.h
  group SelfRecorder
    ./src/SelfRecorder/: SelfRecorder.c SelfRecorder.h
  group Settings
    ./src/Settings/: Settings.cpp Settings.h SettingsChannel.cpp SettingsChannel.h SettingsCursors.cpp SettingsCursors.h SettingsDebug.cpp SettingsDebug.h SettingsDisplay.cpp SettingsDisplay.h SettingsMath.h SettingsMeasures.h SettingsMemory.cpp SettingsMemory.h SettingsNRST.h SettingsService.h SettingsTime.cpp SettingsTime.h SettingsTrig.h SettingsTypes.h
  group Utils
    ../libs/common/Utils/: CommonFunctions.cpp CommonFunctions.h Dictionary.cpp Dictionary.h Map.cpp Map.h Math.cpp Math.h Measures.cpp Measures.h StringUtils.cpp StringUtils.h
    ./src/Utils/: ProcessingSignal.cpp ProcessingSignal.h
  group VCP
    ./src/VCP/: usbd_cdc_interface.cpp usbd_cdc_interface.h usbd_core.cpp usbd_desc.cpp usbd_desc.h VCP.cpp VCP.h
  group VCP/SCPI
    ./src/VCP/SCPI/: channelSCPI.cpp commonSCPI.cpp commonSCPI.h controlSCPI.cpp controlSCPI.h displaySCPI.cpp SCPI.cpp SCPI.h tbaseSCPI.cpp trigSCPI.cpp
