# Keil uVision project Device54.uvprojx, settings and files
target Device54 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F437ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Device
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F437xx, __cplusplus, S8_54
  c misc: --cpp
  c include: ..\_libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\_libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\_libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Src;..\_libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Src;..\_libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Src;..\_libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include;..\_libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\system;..\_libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src\drivers;..\_libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\src;..\_libs\STM32Cube_F4\Drivers\CMSIS\Include;..\_libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\Device54;.\Device54\libs;.\Device54\Ethernet;.\Device54\VCP;..\common
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Device54\Device54.sct
  group HAL
    ../_libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_ll_usb.c
  group USBD
    ../_libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../_libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c
  group USBH
    ../_libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../_libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc_scsi.c usbh_msc.c
  group FatFS
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group LwIP
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c icmp.c igmp.c ip4.c ip4_addr.c etharp.c ip4_frag.c
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c ip.c timeouts.c
    ../_libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group STM32F437lib
    ../common/STM32F437lib/: GPIO.c GPIO.h GPIOdefs.h
  group libs
    ./Device54/libs/: ffconf.h usbh_diskio.h startup_stm32f437xx.s stm32f4xx_hal_conf.h stm32f4xx_hal_msp.cpp stm32f4xx_it.cpp stm32f4xx_it.h system_stm32f4xx.c usbd_conf.cpp usbd_conf.h usbh_conf.cpp usbh_conf.h usbh_diskio.cpp
  group src
    ../common/: commonDefines.h commonDefines.cpp
    ./Device54/: cmsis_gcc.h defines.h FileTree.txt Globals.cpp Globals.h Log.cpp Log.h main.cpp main.h stub.h stub54.cpp Tables.cpp Tables.h
  group Data
    ./Device54/Data/: DataSettings.cpp DataSettings.h DataStorage.cpp DataStorage.h Reader.cpp Reader.h
  group Display
    ../common/Display/: Colors.cpp Colors.h DisplayPrimitives.cpp DisplayPrimitives.h Grid.cpp Grid.h DisplayTypes.h Painter.cpp Painter.h PainterText.cpp Symbols.h
    ./Device54/Display/: Display.cpp Display.h PainterData.cpp PainterData.h PainterMem.cpp PainterMem.h
  group Display/Font
    ./Device54/Display/Font/: Font.cpp Font.h font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc
  group Ethernet
    ./Device54/Ethernet/: app_ethernet.cpp app_ethernet.h Ethernet.cpp Ethernet.h ethernetif.cpp ethernetif.h lwipopts.h TcpSocket.cpp TcpSocket.h
  group FlashDrive
    ./Device54/FlashDrive/: FileManager.cpp FileManager.h FlashDrive.cpp FlashDrive.h
  group FPGA
    ../common/FPGA/: FPGAMath.cpp FPGAMath.h
    ./Device54/FPGA/: FPGA.cpp FPGA.h FPGAextensions.cpp FPGAextensions.h fpgaSettings.cpp FPGATypes.cpp FPGATypes.h
  group Hardware
    ../common/Hardware/: Timer.cpp Timer.h Sound.cpp Sound.h
    ./Device54/Hardware/: FLASH.cpp FLASH.h FSMC.cpp FSMC.h Hardware.cpp Hardware.h RAM.cpp RAM.h RTC.cpp RTC.h
  group Menu
    ../common/Menu/: MenuItems.cpp MenuItems.h MenuItemsLogic.cpp MenuItemsDefs.h Menu.cpp Menu.h MenuItemsGraphics.cpp
    ./Device54/Menu/: MenuPagesNames.h
  group Menu/Pages
    ../common/Menu/Pages/: Definition.cpp Definition.h
    ./Device54/Menu/Pages/: HelpContent.cpp HelpContent.h HelpContentPages.h PageChannels.cpp PageCursors.cpp PageCursors.h PageDebug.cpp PageDisplay.cpp PageDisplay.h PageHelp.cpp PageHelp.h PageMeasures.cpp PageMemory.cpp PageMemory.h PageService.cpp PageTime.cpp PageTrig.cpp
  group Panel
    ./Device54/Panel/: Controls.cpp Controls.h Panel.cpp Panel.h PanelFunctions.h
  group SelfRecorder
    ./Device54/SelfRecorder/: SelfRecorder.c SelfRecorder.h
  group Settings
    ../common/Settings/: commonSettings.cpp
    ./Device54/Settings/: Settings.cpp Settings.h SettingsChannel.cpp SettingsChannel.h SettingsCursors.cpp SettingsCursors.h SettingsDebug.cpp SettingsDebug.h SettingsDisplay.cpp SettingsDisplay.h SettingsMath.h SettingsMeasures.h SettingsMemory.cpp SettingsMemory.h SettingsNew_.h SettingsNRST.h SettingsService.h SettingsTime.cpp SettingsTime.h SettingsTrig.h SettingsTypes.h
  group Utils
    ../common/Utils/: Math.cpp Math.h StringUtils.cpp StringUtils.h Dictionary.cpp Dictionary.h Map.cpp Map.h Measures.cpp Measures.h CommonFunctions.cpp CommonFunctions.h
    ./Device54/Utils/: ProcessingSignal.cpp ProcessingSignal.h
  group VCP
    ./Device54/VCP/: usbd_cdc_interface.cpp usbd_cdc_interface.h usbd_core.cpp usbd_desc.cpp usbd_desc.h VCP.cpp VCP.h
  group VCP/SCPI
    ./Device54/VCP/SCPI/: channelSCPI.cpp commonSCPI.cpp commonSCPI.h controlSCPI.cpp controlSCPI.h displaySCPI.cpp SCPI.cpp SCPI.h tbaseSCPI.cpp trigSCPI.cpp
