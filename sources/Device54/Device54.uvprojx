# Keil uVision project Device54.uvprojx, settings and files
target Device54 (5060960::V5.06 update 7 (build 960)::.\ARMCC536)
  device: STM32F437ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Device +hex
  AfterMake: d:\Keil_v542a\ARM\ARMCC536\bin\fromelf.exe --bin Objects\Device.axf --output S8-54.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32F437xx, S8_54, DEVICE
  c misc: --diag_suppress=161
  c include: ..\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Src;..\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src;..\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Src;..\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Src;..\libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include;..\libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\system;..\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src\drivers;..\libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\src;..\libs\STM32Cube_F4\Drivers\CMSIS\Include;..\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\src;.\src\libs;.\src\libs\FatFS;.\src\libs\HAL;.\src\libs\LwIP;.\src\libs\USBD;.\src\libs\USBH;.\src\Ethernet;..\libs\common;..\libs\common\S8-54
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Device54.sct
  link misc: --diag_suppress=L6776W
  group libs/CMSIS
    ./src/libs/CMSIS/: startup_stm32f437xx.s system_stm32f4xx.c
  group libs/FatFS
    ../libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h
    ../libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
    ./src/libs/FatFS/: ffconf.h
  group libs/HAL
    ../libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_ll_usb.c
    ../libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dma.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_hcd.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_ll_usb.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h
    ./src/libs/HAL/: stm32f4xx_hal_conf.h stm32f4xx_hal_msp.cpp
  group libs/LwIP
    ../libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
    ./src/libs/LwIP/: app_ethernet.cpp app_ethernet.h ethernetif.cpp ethernetif.h lwipopts.h
  group libs/USBD
    ../libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c
    ../libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Inc/: usbd_ctlreq.h usbd_ioreq.h
    ../libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc/: usbd_cdc.h
    ./src/libs/USBD/: usbd_cdc_interface.cpp usbd_cdc_interface.h usbd_core.cpp usbd_desc.cpp usbd_conf.cpp usbd_conf.h usbd_desc.h
  group libs/USBH
    ../libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Inc/: usbh_core.h usbh_ctlreq.h usbh_ioreq.h usbh_pipes.h
    ../libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc/: usbh_msc.h usbh_msc_bot.h usbh_msc_scsi.h
    ../libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ./src/libs/USBH/: usbh_conf.cpp usbh_conf.h usbh_diskio.cpp usbh_diskio.h
  group src
    ./src/: cmsis_gcc.h defines.h globals.cpp globals.h main.cpp main.h Tables.cpp Tables.h
    ../libs/common/: Log.cpp Log.h
  group Data
    ./src/Data/: DataSettings.cpp DataSettings.h DataStorage.cpp DataStorage.h Reader.cpp Reader.h
  group Display
    ../libs/common/Display/: Colors.cpp Colors.h DisplayPrimitives.cpp DisplayPrimitives.h Grid.cpp Grid.h Painter.cpp Painter.h PainterText.cpp PainterPIC24.cpp PainterTextPIC24.cpp
    ./src/Display/: Display.cpp Display.h PainterData.cpp PainterData.h PainterMem.cpp PainterMem.h DisplayTypes.h Display_stm.cpp
  group Display/Font
    ./src/Display/Font/: Font.cpp Font.h font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc
  group FlashDrive
    ./src/FlashDrive/: FileManager.cpp FileManager.h FlashDrive.cpp FlashDrive.h
  group FPGA
    ./src/FPGA/: FPGA.cpp FPGA.h FPGA_stm.cpp FPGAExtensions.cpp FPGAExtensions.h FPGASettings.cpp FPGATypes.cpp FPGATypes.h
    ../libs/common/FPGA/: FPGAMath.cpp FPGAMath.h
  group Hardware
    ./src/Hardware/: CPU.cpp CPU_IT.cpp CPU_RAM.cpp CPU_RTC.cpp FLASH.cpp FSMC.cpp Hardware.cpp Panel.cpp CPU.h FLASH.h FSMC.h Hardware.h Panel.h VCP.cpp VCP.h Controls.h
    ../libs/common/Hardware/: Sound.cpp Timer.cpp Sound.h Timer.h
    ../libs/common/Hardware/Controls/: Controls54.cpp Controls54.h
  group Hardware/stm32
    ../libs/common/Hardware/stm32/: stm32.cpp stm32.h
    ../libs/common/Hardware/stm32/4XX/: Timer4XX.h Timer4XX.cpp stm437.cpp stm437.h
  group LAN
    ./src/LAN/: LAN.h LAN.cpp LTCP.cpp TCP.h
  group Menu
    ./src/Menu/: MenuPagesNames.h
    ../libs/common/Menu/: Menu.cpp Menu.h MenuItems.cpp MenuItems.h MenuItemsDefs.h MenuItemsGraphics.cpp MenuItemsLogic.cpp
  group Menu/Pages
    ./src/Menu/Pages/: HelpContent.cpp HelpContent.h HelpContentPages.h PageChannels.cpp PageCursors.cpp PageCursors.h PageDebug.cpp PageDisplay.cpp PageDisplay.h PageHelp.cpp PageHelp.h PageMeasures.cpp PageMemory.cpp PageMemory.h PageService.h PageService.cpp PageTime.cpp PageTrig.cpp PageChannels.h PageTime.h PageTrig.h
    ../libs/common/Menu/Pages/: Definition.cpp Definition.h
  group SCPI
    ./src/SCPI/: SCPI.h SCPI.cpp StringUtilsSCPI.h StringUtilsSCPI.cpp SCPI.txt
  group SCPI/Functions
    ./src/SCPI/Functions/: ChannelSCPI.cpp CommonSCPI.cpp CommonSCPI.h DisplaySCPI.cpp TrigSCPI.cpp ChannelSCPI.h DisplaySCPI.h TrigSCPI.h MathSCPI.cpp MathSCPI.h TimebaseSCPI.cpp TimebaseSCPI.h AcquireSCPI.cpp AcquireSCPI.h CursorSCPI.cpp CursorSCPI.h MeasureSCPI.cpp MeasureSCPI.h UtilitySCPI.cpp UtilitySCPI.h MemorySCPI.cpp MemorySCPI.h
  group SelfRecorder
    ./src/SelfRecorder/: SelfRecorder.h
  group Settings
    ./src/Settings/: Settings.cpp Settings.h SettingsChannel.cpp SettingsChannel.h SettingsCursors.cpp SettingsCursors.h SettingsDebug.cpp SettingsDebug.h SettingsDisplay.cpp SettingsDisplay.h SettingsMath.h SettingsMeasures.h SettingsMemory.cpp SettingsMemory.h SettingsNRST.h SettingsService.h SettingsTime.cpp SettingsTime.h SettingsTrig.h SettingsTypes.h
  group Utils
    ./src/Utils/: Buffer.h Buffer.cpp Dictionary.h Dictionary.cpp ProcessingSignal.h ProcessingSignal.cpp Stack.h Stack.cpp String.h String.cpp StringUtils.h StringUtils.cpp
    ../libs/common/Utils/: CommonFunctions.h CommonFunctions.cpp Map.h Map.cpp Math.h Math.cpp Measures.h Measures.cpp
