# Keil uVision project Loader54.uvprojx, settings and files
target Loader54 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F437ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DeviceBoot
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F437xx, __cplusplus, S8_54
  c misc: --cpp
  c include: .\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;.\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\libs\STM32Cube_F4\Drivers\CMSIS\Include;.\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;.\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;.\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;.\Loader;.\Loader\libs;.\common
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Loader\Loader54.sct
  group FatFS
    ./libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c diskio.h ff.h ff_gen_drv.h
    ./libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group HAL
    ./libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_ll_usb.c
  group USBH
    ./libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ./libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group src
    ./Loader/: defines.h globals.c globals.h Log.h main.cpp main.h
  group libs
    ./Loader/libs/: ffconf.h startup_stm32f437xx.s stm32f4xx_hal_conf.h stm32f4xx_hal_msp.cpp system_stm32f4xx.c usbh_conf.cpp usbh_conf.h usbh_diskio.cpp usbh_diskio.h
  group Display
    ./Loader/Display/: Colors.cpp Colors.h Display.cpp Display.h DisplayTypes.h Painter.cpp Painter.h PainterC.h PainterText.cpp PainterText.h
  group Display/fonts
    ./Loader/Display/font/: Font.cpp Font.h font8.inc
  group FlashDrive
    ./Loader/FlashDrive/: FlashDrive.cpp FlashDrive.h
  group Hardware
    ./Loader/Hardware/: FLASH.cpp FLASH.h FSMC.cpp FSMC.h Hardware.cpp Hardware.h
    ./common/Hardware/: Timer.cpp Timer.h
  group Panel
    ./Loader/Panel/: Controls.c Controls.h Panel.cpp Panel.h
  group Settings
    ./Loader/Settings/: Settings.cpp Settings.h SettingsTypes.h
  group Utils
    ./common/Utils/: Dictionary.cpp Dictionary.h StringUtils.cpp StringUtils.h
  group FPGA
    ./Loader/FPGA/: FPGATypes.h
