# Keil uVision project Loader54-Open7XX.uvprojx, settings and files
target Loader54-Open7XX (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Loader54-Open7XX
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F746xx, __cplusplus, S8_54
  c misc: --cpp
  c include: ..\libs\STM32Cube_F7\Drivers\STM32F7xx_HAL_Driver\Inc;..\libs\STM32Cube_F7\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\libs\STM32Cube_F7\Drivers\CMSIS\Include;..\libs\STM32Cube_F7\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\libs\STM32Cube_F7\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\libs\STM32Cube_F7\Middlewares\Third_Party\FatFs\src;.\src;.\src\libs;..\libs\common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Loader54.sct
  group FatFS
    ../libs/STM32Cube_F7/Middlewares/Third_Party/FatFs/src/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h
    ../libs/STM32Cube_F7/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group HAL
    ../libs/STM32Cube_F7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_flash.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_spi.c stm32f7xx_ll_fmc.c stm32f7xx_ll_usb.c
  group USBH
    ../libs/STM32Cube_F7/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../libs/STM32Cube_F7/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group src
    ./src/: defines.h globals.c globals.h main.cpp main.h
  group libs
    ./src/libs/: ffconf.h usbh_conf.cpp usbh_conf.h usbh_diskio.cpp usbh_diskio.h stm32f7xx_hal_conf.h system_stm32f7xx.c startup_stm32f746xx.s stm32f7xx_hal_msp.cpp stm32f7xx_it.c stm32f7xx_it.h
  group Display
    ./src/Display/: Colors.cpp Colors.h Display.cpp Display.h DisplayTypes.h Painter.cpp Painter.h PainterC.h PainterText.cpp PainterText.h
  group Display/fonts
    ./src/Display/font/: Font.cpp Font.h font8.inc
  group FlashDrive
    ./src/FlashDrive/: FlashDrive.cpp FlashDrive.h
  group Hardware
    ./src/Hardware/: FLASH.cpp FLASH.h FSMC.cpp FSMC.h Hardware.h Hardware-open.cpp
    ../libs/common/Hardware/: Timer.cpp Timer.h
  group Panel
    ./src/Panel/: Controls.c Controls.h Panel.cpp Panel.h
  group Settings
    ./src/Settings/: Settings.cpp Settings.h SettingsTypes.h
  group Utils
    ../libs/common/Utils/: Dictionary.cpp Dictionary.h StringUtils.cpp StringUtils.h Math.cpp Math.h
  group FPGA
    ./src/FPGA/: FPGATypes.h
